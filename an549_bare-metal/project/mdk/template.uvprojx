# Keil uVision project template.uvprojx, settings and files
target V2M-MPS3-CM85 (6210000::V6.21::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.Cortex_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x30000000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x10000000,0x00200000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ESEL ELITTLE
  output: template
  c flags: oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: LCD_MIRROR_X=1,GLCD_MIRROR_Y=0,LV_USE_DEMO_BENCHMARK
  c misc: -Omax
  c include: ..\..\..\common\platform;..\..\;..\..\..\common\platform\mps3\v2m_mps3;..\..\..\common\platform\mps3;..\..\..\ui
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\MPS3_CM55_DTCM.sct
  link misc: --entry=Reset_Handler
--diag_suppress=6314,6329,6848
  group Source Files
    ../../: main.c app_cfg.h
  group platform
    ../../../common/platform/: app_platform.c Board_GLCD.h GLCD_Fonts.c platform.h
  group bsp_mps3
    ../../../common/platform/mps3/: GLCD_V2M-MPS3_AN540.c platform_mps3.c stdout_USART.c GLCD_Config.h Touch_V2M-MPS3.c
software components: CMSIS-Compiler:CORE 1.0.0, CMSIS-Compiler:STDOUT:ITM 1.0.0, CMSIS:CORE 6.0.0, Device:Startup 2.2.0, Utilities:perf_counter:Core 2.3.0
